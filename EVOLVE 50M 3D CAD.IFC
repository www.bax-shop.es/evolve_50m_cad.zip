Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: EVOLVE 50M 3D CAD.IFC
Time: 2022-07-27T16:07:15
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Evolve 50M Amp Panel
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 50M Bottom Cover
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 50M Column Handle
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 50M EV Logo
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 50M Grille
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 50M Pole
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 50M Pole Cap (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 50M Rear Enclosure
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 50M Rubber Foot (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 50M Sub Cabinet Handle Box (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 50M Sub Handle
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 50M Sub Handle Cover
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 50M Sub Top Cover
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 50M Subwoofer Cabinet
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 50M Subwoofer Grille
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 50M Top Cover
In: Default Storey
PredefinedType: ELEMENT; Material: 0
